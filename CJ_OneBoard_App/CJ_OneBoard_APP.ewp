# IAR project CJ_OneBoard_APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CM5164JH01032 Microchip PIC32CM5164JH01032
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __PIC32CM5164JH01032__
  ICCARM.CCIncludePath2: applications\inc; drivers\inc; startup; Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CJ_App.bin
  ILINK.IlinkOutputFile: CJ_OneBoard_APP.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __PIC32CM5164JH01032__
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group applications/inc
    applications/inc/: appConfig.h Reprogram.h crc32.h UDS.h XCP.h lin_task.h pds.h OSPControl.h SRGBControl.h Verification.h sys_init.h
  group applications/src
    applications/src/: crc32.c Reprogram.c UDS.c Verification.c XCP.c lin_task.c pds.c OSPControl.c SRGBControl.c sys_init.c
  group driver/inc
    drivers/inc/: power_device.h clock_device.h flash_device.h gpio_device.h lin_device.h systick_device.h
  group driver/src
    drivers/src/: power_device.c clock_device.c flash_device.c gpio_device.c lin_device.c systick_device.c
  group Startup
    startup/: startup_pic32cmjh01.h startup_pic32cmjh01.c
  group Download Setup
    debugger/: CJ_PIC32CM5164JH.board CJ_PIC32CM5164JH_main.flash CJ_PIC32CM_BootUnlock.mac
